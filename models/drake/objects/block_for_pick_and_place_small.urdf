Commit message: Updated placement functions

File: models/drake/objects/block_for_pick_and_place_small.urdf (robot description, URDF)
Before this commit: robot simple_cuboid, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=0.044 0.044 0.069; collision sphere radius=1e-7
